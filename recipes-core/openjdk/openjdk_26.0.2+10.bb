require openjdk-common.inc

SRCREV = "fa67dfdcec4b8211dc6c3d016903ca1c7b4f6cb9"
