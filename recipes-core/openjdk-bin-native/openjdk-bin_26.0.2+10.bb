require openjdk-bin.inc

LIC_FILES_CHKSUM:append = "\
    file://jdk-${PV}/legal/java.prefs/ASSEMBLY_EXCEPTION;md5=d54e5b1b11ce92d8abc22e8e756f54bd \
"
SRC_URI[sha256sum] = "56f768372f6ca1e2eb4c5f46b78f627949e8dcfe9c9723926cf45a45faf35802"
