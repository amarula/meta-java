require openjdk-bin.inc

LIC_FILES_CHKSUM:append = "\
    file://jdk-${PV}/legal/java.prefs/ASSEMBLY_EXCEPTION;md5=d54e5b1b11ce92d8abc22e8e756f54bd \
"
SRC_URI[sha256sum] = "dbb698396d478e7fa2b1e50f4103324b2a99b90569ee27c33f2261f9215cf41e"
