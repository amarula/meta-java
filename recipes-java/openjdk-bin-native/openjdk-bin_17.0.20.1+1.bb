require openjdk-bin.inc

LIC_FILES_CHKSUM:append = "\
    file://jdk-${PV}/legal/java.prefs/ASSEMBLY_EXCEPTION;md5=d94f7c92ff61c5d3f8e9433f76e39f74 \
"
SRC_URI[sha256sum] = "3808d1d15e3ec6bd5b84057fb5d84c33d8a1536a258146bcea2e603fc726e08e"
