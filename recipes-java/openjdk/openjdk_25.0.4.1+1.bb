require openjdk-common.inc

SRCREV = "7b65d74bcbd7c3a0b4c1f5c5bd85e64aa2e51b4a"
